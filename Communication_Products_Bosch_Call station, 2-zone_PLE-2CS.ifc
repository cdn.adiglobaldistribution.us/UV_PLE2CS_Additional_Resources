Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: Project Number
Time: 2025-01-24T11:22:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.30.74 - Exporter 21.1.30.74 - Alternate UI 21.1.30.74
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 24 11:22:17 2025 * Host: LIS-C-001LH * Database: C:\Users\moa2ovr\AppData\Local\Temp\379fab2f-23b7-45ca-9f87-cc5be4bcbf6e\a56d3737-223b-4e2e-b3a2-b0c24eb093ef\ifc * Database version: 5507 * Database creation date: Fri Jan 24 11:22:16 2025 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Jan 24 11:22:17 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 24 11:22:17 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingSystemCommon - Reference: Project Information; sets with these values: 2
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey: Level:Story Level, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_BuildingStoreyCommon - Reference: Story Level

# IfcDistributionPort, Port_412070
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcElectricAppliance: Call station, 2-zone, Communication_Products_Bosch_Call station, 2-zone_PLE-2CS:Call station, 2-zone_PLE-2CS:412070
In: Level 1
Type - Description: Pr_75_75_94_60 Paging microphones; Material: Bosch_Ral 9017
Type - Pset_ElectricApplianceTypeCommon - Reference: Call station, 2-zone_PLE-2CS
Type - Pset_EnvironmentalImpactIndicators - Reference: Call station, 2-zone_PLE-2CS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Material: Bosch_Ral 9017, Bosch_Silver, Bosch_Ral 9017_Button, Bosch_silver_Button
Pset_ElectricApplianceTypeCommon - sets with these values: 2
